## Kconfig
```kconfig
menuconfig DRIVERS_LIGHTHOUSE_BITCRAZE_LIGHTHOUSE
	bool "lighthouse_bitcraze"
	default n
	---help---
		Enable support for lighthouse bitcraze
```
